# Keil uVision project H5.uvprojx, settings and files
target H5 (6240000::V6.24::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: H5 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6LangP=3 wLevel=3
  c define: LV_LVGL_H_INCLUDE_SIMPLE,NDEBUG
  c misc: -include global-config.h -fdebug-macro -fno-short-wchar
  c include: ..\MDK;..\Config;..\Applications\main;..\Drivers\bsp\Include;..\Drivers\component\Display;..\Drivers\component\Display\DBI;..\Drivers\component\Display\DPI;..\Drivers\component\Display\DSI;..\Drivers\component\Display\DSI\JD9365DA;..\Drivers\component\GAUPort;..\Drivers\component\USB\VCP;..\Drivers\driver;..\Libraries\CMSIS\Include;..\Libraries\Device\MegaHunt\MH245x\Include;..\Libraries\MH245x_StdPeriph_Driver\inc;..\Libraries\OSS\lvgl\9.2.2;..\Libraries\OSS\lvgl\9.2.2\src\draw;..\Applications;..\Libraries\OSS\littlefs\2.11.3;..\Libraries\SEGGER\SystemView\SystemView_Src\Config;..\Libraries\SEGGER\SystemView\SystemView_Src\SEGGER;..\Libraries\SEGGER\SEGGER_RTT_V700\RTT;..\Libraries\USB-ESL\Target;..\Libraries\USB-ESL;..\Applications;..\Applications\res
  memory RVCT4: ROM 0x8001000 size 0x1fff000
  memory RVCT9: RAM 0x20000000 size 0x900000
  scatter file: .\ARMClang.sct
  group Config
    ../Config/: global-config.h lv_conf.h USBVendorConfig.h
    ../Libraries/SEGGER/SEGGER_RTT_V700/RTT/: SEGGER_RTT_Conf.h
    ./: memory.h
  group App/main
    ../Applications/main/: main.c jpeg_hw.c at.c ui_ota.c littlefs.c log.c config.c ui_menu.c usb.c ui_selftest.c
  group App/res
    ../Applications/res/: img.c update_bg_dark.c update_progress_bg_dark.c update_progress_fg_dark.c lv_font_puhui_40.c lv_font_puhui_42.c text.c menu_logs.c menu_reset.c menu_upgrade.c menu_back.c menu_bg.c
  group Bsp
    ../Drivers/bsp/Source/: DisplayBSP.c DPI-DisplayBSP.c DSI-DisplayBSP.c SDRAMBSP.c USBBSP.c USBMSD.c USBVCP.c LVGLPort.c lfs_msd.c VirtualFatFS.c
  group Component
    ../Drivers/component/Display/: Display.c
    ../Drivers/component/Display/DPI/: DisplayDPI.c
    ../Drivers/component/Display/DSI/: DisplayDSI.c
    ../Drivers/component/Display/DSI/JD9365DA/: DSI-JD9365DA.c
    ../Drivers/component/GAUPort/: GAUPort.c
  group Driver
    ../Drivers/driver/: flash.c key.c uart.c pwm.c tmr.c io.c crc.c update.c
  group Cmsis
    ../Libraries/Device/MegaHunt/MH245x/Source/: system_mh2457.c startup_mh2457.c
  group Lib/littlefs
    ../Libraries/OSS/littlefs/2.11.3/: lfs.c lfs_crc.c lfs_util.c
  group Lib/MH245x_StdPeriph
    ../Libraries/MH245x_StdPeriph_Driver/src/: mh245x_adc.c mh245x_cache.c mh245x_crc.c mh245x_dma.c mh245x_dsi.c mh245x_exti.c mh245x_fsmc.c mh245x_gpio.c mh245x_i2c.c mh245x_iwdg.c mh245x_misc.c mh245x_pwr.c mh245x_qspi.c mh245x_rtc.c mh245x_sdio.c mh245x_sdram.c mh245x_spi.c mh245x_sysctrl.c mh245x_tim.c mh245x_usart.c mh245x_wwdg.c peripheral.c mh245x_ltdc.c mh245x_hspi.c mh245x_jpeg.c mh245x_dma2d.c
  group Lib/lvgl
    ../Libraries/OSS/lvgl/9.2.2/src/: lv_init.c
    ../Libraries/OSS/lvgl/9.2.2/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../Libraries/OSS/lvgl/9.2.2/src/display/: lv_display.c
    ../Libraries/OSS/lvgl/9.2.2/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Libraries/OSS/lvgl/9.2.2/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../Libraries/OSS/lvgl/9.2.2/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../Libraries/OSS/lvgl/9.2.2/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Libraries/OSS/lvgl/9.2.2/src/indev/: lv_indev.c lv_indev_scroll.c
    ../Libraries/OSS/lvgl/9.2.2/src/layouts/: lv_layout.c
    ../Libraries/OSS/lvgl/9.2.2/src/layouts/grid/: lv_grid.c
    ../Libraries/OSS/lvgl/9.2.2/src/layouts/flex/: lv_flex.c
    ../Libraries/OSS/lvgl/9.2.2/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
    ../Libraries/OSS/lvgl/9.2.2/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ../Libraries/OSS/lvgl/9.2.2/src/osal/: lv_os_none.c lv_os.c
    ../Libraries/OSS/lvgl/9.2.2/src/stdlib/: lv_mem.c
    ../Libraries/OSS/lvgl/9.2.2/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Libraries/OSS/lvgl/9.2.2/src/themes/: lv_theme.c
    ../Libraries/OSS/lvgl/9.2.2/src/themes/default/: lv_theme_default.c
    ../Libraries/OSS/lvgl/9.2.2/src/themes/simple/: lv_theme_simple.c
    ../Libraries/OSS/lvgl/9.2.2/src/themes/mono/: lv_theme_mono.c
    ../Libraries/OSS/lvgl/9.2.2/src/tick/: lv_tick.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/animimage/: lv_animimage.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/bar/: lv_bar.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/canvas/: lv_canvas.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/image/: lv_image.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/label/: lv_label.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/property/: lv_image_properties.c lv_label_properties.c lv_obj_properties.c lv_style_properties.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/span/: lv_span.c
    ../Libraries/OSS/lvgl/9.2.2/src/others/sysmon/: lv_sysmon.c
    ../Libraries/OSS/lvgl/9.2.2/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Libraries/OSS/lvgl/9.2.2/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Libraries/OSS/lvgl/9.2.2/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Libraries/OSS/lvgl/9.2.2/src/others/observer/: lv_observer.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/spinner/: lv_spinner.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/msgbox/: lv_msgbox.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/arc/: lv_arc.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Libraries/OSS/lvgl/9.2.2/src/widgets/button/: lv_button.c
  group Lib/usb-esl
    ../Libraries/USB-ESL/: CircularBuffer.c InterfaceCDC.c InterfaceMSD.c InterfaceSerial.c InterfaceSetup.c USBCoreZoffy.c USBDevice.c USBInterface.c
    ../Libraries/USB-ESL/Target/: USBTargetMH2457.c
  group Segger/RTT
    ../Libraries/SEGGER/SystemView/SystemView_Src/SEGGER/: SEGGER_RTT.c
    ../Libraries/SEGGER/SEGGER_RTT_V700/RTT/: SEGGER_RTT_printf.c SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_Syscalls_KEIL.c
